options:
  parameters:
    generate_options: qt_gui
    id: fm_demodulate
    output_language: python
    title: fm demodulate
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: '140000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: audio_rate
    deviation: '10000'
    gain: '2'
    tau: '75E-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    bw0: '1000000'
    freq0: frequency
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
    update_time: '0.00001'
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', audio_sink_0, '0']
- [analog_fm_demod_cf_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', analog_fm_demod_cf_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_1, '0']

metadata:
  file_format: 1
