options:
  parameters:
    generate_options: qt_gui
    id: fm_demodulate
    output_language: python
    title: fm demodulate
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: '446055000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: blocks_file_descriptor_source_0
  id: blocks_file_descriptor_source
  parameters:
    fd: '51779606'
    repeat: 'True'
    type: byte
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: 100e6
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_descriptor_source_0, '0', digital_gfsk_mod_0, '0']
- [digital_gfsk_mod_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
